# Copyright (c) 2020 Wind River Systems, Inc.
# SPDX-License-Identifier: BSD-3-Clause

IMAGE_INSTALL_append += "epiphany"
IMAGE_INSTALL_append += "mi-simulator"
IMAGE_INSTALL_append += "mi-dashboard"
