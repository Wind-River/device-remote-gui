# Copyright (c) 2020 Wind River Systems, Inc.
# SPDX-License-Identifier: BSD-3-Clause

IMAGE_INSTALL += "mi-dashboard"
IMAGE_INSTALL += "mi-simulator"

IMAGE_FSTYPES += "ext4"
IMAGE_FSTYPES += "wic"
